inherit resin-u-boot
