# Describes the path to our XSA/HDF file.
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

HDF_BASE = "file://"
HDF_PATH = "/home/jcepeda/etc/system_top.hdf"
HDF_NAME = "system_top.hdf"
